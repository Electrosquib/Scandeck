options:
  parameters:
    generate_options: qt_gui
    id: ControlChannelScan
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: num_bins
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /Users/levifarinas/fft.bin
    type: float
    vlen: num_bins
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1'
    type: float
    vlen: num_bins
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: num_bins
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_bins
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: bypassed}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: num_bins
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(num_bins)
  states: {}
- name: freq
  id: parameter
  parameters:
    value: 851e6
  states: {}
- name: num_bins
  id: parameter
  parameters:
    value: '2048'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: num_bins
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '.01'
    type: float
    vlen: num_bins
  states: {state: bypassed}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: freq
    gain: '32'
    samp_rate: samp_rate
    type: fc32
    vga: '32'
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_nlog10_ff_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [dc_blocker_xx_0, '0', blocks_stream_to_vector_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_head_0, '0']
- [soapy_hackrf_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
